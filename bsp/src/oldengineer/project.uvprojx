# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __TARGET_FPU_VFP, USE_HAL_DRIVER, __FPU_PRESENT=1U, STM32F446xx, __ARM_FEATURE_DSP=1, ARM_MATH_ROUNDING, ARM_MATH_MATRIX_CHECK, __FPU_USED=1U, ARM_MATH_CM4
  c include: .;..\..\..\include;applications\Main;applications\Robo_Ctrl;applications\Robo_Data;applications\Robo_Motor;applications\Robo_Music;applications\Robo_RefSystemCom;applications\Robo_RemoteCtrl;applications\Robo_Resolve;applications\Robo_UI;applications\SPIMaster;board;board\CubeMX_Config\Inc;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\libraries\HAL_Drivers\drv_flash;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common;..\PublicLib\Hardware\Buzzer;..\PublicLib\Hardware\Remote;..\PublicLib\Hardware\RGBLight;..\PublicLib\Hardware\SPI_Master;..\PublicLib\Monitor;..\PublicLib\Software\CPU_Usage;..\PublicLib\Software\DataServer;..\PublicLib\Software\Filter;..\PublicLib\Software\List;..\PublicLib\Software\Menu;..\PublicLib\Software\Motor;..\PublicLib\Software\Pid;..\PublicLib\Software\Queue;..\PublicLib\Software\SetPlanning;..\PublicLib\Software\Utils;..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\libraries\STM32F4xx_HAL\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Main
    applications/Main/: Cpu_reset.c main.c drv_thread.h
  group Robo_Ctrl
    applications/Robo_Ctrl/: app_RoboCtrl.c app_RoboRemote_Ctrl.c
  group Robo_Data
    applications/Robo_Data/: drv_RemoteCtrl_data.c drv_Robo_data.c drv_canthread.c drv_gyroscope_data.c func_Dataserver.c func_UI_data.c mod_Can_data.c drv_Robo_data.h
  group Robo_Motor
    applications/Robo_Motor/: drv_encoder.c drv_motor_Locked.c func_ArmMotor_Ctrl.c func_ChassisMotor_Ctrl.c func_Gpio_Ctrl.c func_ImageMotor_Ctrl.c func_encoderCail.c
  group Robo_Music
    applications/Robo_Music/: drv_MusicLibrary.c func_MusicPlayer.c
  group Robo_RefSystemCom
    applications/Robo_RefSystemCom/: drv_CRC.c fun_protocolRef.c mod_RefSystem.c
  group Robo_RemoteCtrl
    applications/Robo_RemoteCtrl/: app_KeymouseData_Ctrl.c app_RemoteCallback_Set.c mod_RoboStateCtrl.c
  group Robo_Solve
    applications/Robo_Resolve/: drv_Arm_Solve.c drv_Chassis_Solve.c drv_Image_Solve.c drv_Setplanning3D.c drv_Vector.c func_Setplanning3D.c
  group Robo_UI
    applications/Robo_UI/: app_ui.c drv_drawUI.c drv_uiSend.c fun_drawCustomUI.c fun_ui_list.c ui_interface.c CustomUI_GraphParameters.h
  group SPIDriver
    applications/SPIMaster/: drv_HALmain.c drv_HW_SPI.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f446xx.s
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_pwm.c drv_spi.c drv_can.c drv_wdt.c drv_common.c
    ../libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
  group cpu
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/can/: can.c
    ../../../components/drivers/misc/: pin.c rt_drv_pwm.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/watchdog/: watchdog.c
  group libc
    ../../../components/libc/compilers/common/: time.c
  group Public/Hardware/Buzzer
    ../PublicLib/Hardware/Buzzer/: drv_buzzer.c
  group Public/Hardware/Remote
    ../PublicLib/Hardware/Remote/: drv_remote.c
  group Public/Hardware/Light
    ../PublicLib/Hardware/RGBLight/: drv_rgblight.c
  group Public/Hardware/SPI_Master
    ../PublicLib/Hardware/SPI_Master/: drv_SPICAN.c
  group Public/Monitor
    ../PublicLib/Monitor/: drv_monitor.c mod_Monitor.c app_monitor.c
  group Public/Hardware/Cpu_Usage
    ../PublicLib/Software/CPU_Usage/: drv_cpuusage.c
  group Public/Software/DataServer
    ../PublicLib/Software/DataServer/: drv_dataserve.c
  group Public/Software/Filter
    ../PublicLib/Software/Filter/: drv_ExactSmooth.c drv_AccClamp.c
  group Public/Software/list
    ../PublicLib/Software/List/: list_d.c
  group Public/Software/Menu
    ../PublicLib/Software/Menu/: drv_Key_Set.h func_Key_Record.c mod_KeyCtrl.c
  group Public/Software/Motor
    ../PublicLib/Software/Motor/: drv_motor.c
  group Public/Software/Pid
    ../PublicLib/Software/Pid/: pid.c
  group Public/Software/Queue
    ../PublicLib/Software/Queue/: drv_Queue.c
  group Public/Software/SetPlanning
    ../PublicLib/Software/SetPlanning/: drv_SetPlanning.c
  group Public/Software/Utils
    ../PublicLib/Software/Utils/: drv_utils.c
  group STM32_HAL
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_spi.c stm32f4xx_hal_qspi.c stm32f4xx_hal_can.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_lptim.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c
software components: CMSIS:CORE 5.2.0, CMSIS:DSP 1.6.0
