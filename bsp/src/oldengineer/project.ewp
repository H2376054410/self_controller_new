# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F446RE ST STM32F446RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F446xx; USE_HAL_DRIVER; ARM_MATH_CM4; ARM_MATH_MATRIX_CHECK; ARM_MATH_ROUNDING; __FPU_PRESENT=1U; __TARGET_FPU_VFP; __FPU_USED=1U; __ARM_FEATURE_DSP=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\finsh; applications\Robo_Data; ..\..\..\components\drivers\include; ..\PublicLib\Hardware\Remote; applications\Robo_RemoteCtrl; ..\libraries\HAL_Drivers\drv_flash; ..\..\..\components\libc\compilers\common; board\CubeMX_Config\Inc; ..\PublicLib\Software\Motor; ..\PublicLib\Software\DataServer; ..\PublicLib\Software\Pid; ..\PublicLib\Software\SetPlanning; .; ..\PublicLib\Hardware\RGBLight; ..\PublicLib\Monitor; ..\libraries\HAL_Drivers\config; board; applications\Arm_Slove; ..\..\..\components\drivers\spi; ..\libraries\HAL_Drivers; ..\PublicLib\Software\Filter; ..\PublicLib\Hardware\SPI_Master; ..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc; applications\Test_3508; applications\Robo_Motor; ..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\include; ..\PublicLib\Software\CPU_Usage; applications\Robo_Ctrl; ..\..\..\libcpu\arm\common; ..\..\..\libcpu\arm\cortex-m4; ..\PublicLib\Hardware\Buzzer; applications\Main; ..\PublicLib\Software\Utils; applications\SPIMaster; ..\PublicLib\Software\Menu; ..\libraries\STM32F4xx_HAL\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Arm_Solve
    applications/Arm_Slove/: drv_Robo_Solve.c func_Arm_Pos.c func_Arm_Pos.h drv_Robo_Solve.h
  group Main
    applications/Main/: main.c drv_thread.h drv_thread.h
  group Robo_Ctrl
    applications/Robo_Ctrl/: app_Arm.c app_Arm.h
  group Robo_Data
    applications/Robo_Data/: app_RoboCtrl_data.c drv_Robo_data.c drv_canthread.c func_Can_data.c drv_canthread.h func_Can_data.h drv_Robo_data.h app_RoboCtrl_data.h
  group Robo_Motor
    applications/Robo_Motor/: func_Motor_Locked.c mod_ArmMotor_Ctrl.c func_Motor_Locked.h mod_ArmMotor_Ctrl.h
  group Robo_RemoteCtrl
    applications/Robo_RemoteCtrl/: Engineer_Ctrl.c app_Keymouse_data.c app_RoboRemote_Ctrl.c app_RemoteCallback_Set.h app_KeymouseData_Ctrl.h Engineer_Ctrl.h
  group SPIDriver
    applications/SPIMaster/: drv_HALmain.c drv_HW_SPI.c
  group Test_3508
    applications/Test_3508/: SPI_Test.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f446xx.s
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_pwm.c drv_spi.c drv_can.c drv_wdt.c drv_common.c
    ../libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
  group cpu
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_iar.S
  group DeviceDrivers
    ../../../components/drivers/can/: can.c
    ../../../components/drivers/misc/: pin.c rt_drv_pwm.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/watchdog/: watchdog.c
  group finsh
    ../../../components/finsh/: shell.c cmd.c msh.c
  group libc
    ../../../components/libc/compilers/common/: time.c
  group Public/Hardware/Buzzer
    ../PublicLib/Hardware/Buzzer/: drv_buzzer.c
  group Public/Hardware/Remote
    ../PublicLib/Hardware/Remote/: drv_remote.c
  group Public/Hardware/Light
    ../PublicLib/Hardware/RGBLight/: drv_rgblight.c
  group Public/Hardware/SPI_Master
    ../PublicLib/Hardware/SPI_Master/: drv_SPICAN.c
  group Public/Monitor
    ../PublicLib/Monitor/NoMonitor/: app_monitor.h
  group Public/Hardware/Cpu_Usage
    ../PublicLib/Software/CPU_Usage/: drv_cpuusage.c
  group Public/Software/DataServer
    ../PublicLib/Software/DataServer/: drv_dataserve.c
  group Public/Software/Filter
    ../PublicLib/Software/Filter/: drv_ExactSmooth.c
  group Public/Software/Menu
    ../PublicLib/Software/Menu/: drv_Key_Set.h func_Key_Record.c mod_KeyCtrl.c
  group Public/Software/Motor
    ../PublicLib/Software/Motor/: drv_motor.c
  group Public/Software/Pid
    ../PublicLib/Software/Pid/: pid.c
  group Public/Software/SetPlanning
    ../PublicLib/Software/SetPlanning/: drv_SetPlanning.c
  group Public/Software/Utils
    ../PublicLib/Software/Utils/: drv_utils.c
  group STM32_HAL
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_spi.c stm32f4xx_hal_qspi.c stm32f4xx_hal_can.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_lptim.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c
